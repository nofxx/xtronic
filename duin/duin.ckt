* /usr/bin/gnetlist -v -g spice-sdb -o /home/nofxx/git/xtronic/duin/duin.ckt /home/nofxx/git/xtronic/duin/duin.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
.end
